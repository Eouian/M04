# Keil uVision project test3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F130G6 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.1
  cpu: IRAM(0x20000000,0x01000) IROM(0x08000000,0x08000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\Library\Include;..\User;..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../CMSIS/: system_gd32f1x0.c
  group Startup
    ../Startup/: startup_gd32f1x0.s
  group Library
    ../Library/Source/: gd32f1x0_adc.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_misc.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
  group User
    ../User/: gd32f1x0_it.c main.c systick.c
    ./: RTC6705.c SPI.c SPI.h RTC6705.h ADC.c PWM.c PWM.h ADC.h PID.h PID.c SmartAudio.c SmartAudio.h UART.c UART.h
